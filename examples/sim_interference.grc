<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sim_interference</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac</value></param>
<param><key>value</key><value>map(lambda x: int(x), list(digital.packet_utils.default_access_code))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_hex</value></param>
<param><key>value</key><value>[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb1</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb2</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>data</key><value>ac_hex</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>rxmod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb1</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>sps*nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxmod</value></param>
<param><key>value</key><value>digital.generic_mod(mod, False, sps, True, eb1, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps2</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb2</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_1</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1e-2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>num*8/4*sps2, 10000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"su_pkt"</value></param>
<param><key>packet_len</key><value>80</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"qam_pkt"</value></param>
<param><key>packet_len</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[1,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0] + ac</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>0.95</value></param>
<param><key>freq_offset</key><value>0.02</value></param>
<param><key>noise_voltage</key><value>1e-3</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbols</key><value>modulated_sync_word</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold</key><value>0.999</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>eb1</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_qam_mod</key>
<param><key>id</key><value>digital_qam_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>eb2</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>16</value></param>
<param><key>samples_per_symbol</key><value>sps2</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lsa_eng_det_cc</key>
<param><key>id</key><value>lsa_eng_det_cc_0</value></param>
<param><key>bin</key><value>5</value></param>
<param><key>threshold</key><value>-20</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_qam_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>lsa_eng_det_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_eng_det_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
