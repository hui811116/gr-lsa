<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lsa_su_tx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cross_ac</value></param>
<param><key>value</key><value>digital.packet_utils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"addr=192.168.10.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_ctrl</value></param>
<param><key>value</key><value>2.3e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1-1j, 1+1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_bytes</value></param>
<param><key>value</key><value>[int(cross_ac[i:i+8],2) for i in range(0,len(cross_ac),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_points</value></param>
<param><key>value</key><value>[mod.points()[pre_sym[i]] for i in range(0,len(pre_sym))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_sym</value></param>
<param><key>value</key><value>[int(cross_ac[i:i+bps],2) for i in range(0,len(cross_ac),bps)]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>bps</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>len(pre_bytes)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>8</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>pre_bytes</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>mod.points()</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>gain_omega</key><value>0.000225</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.0002</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lsa_chip_mapper_bb</key>
<param><key>id</key><value>lsa_chip_mapper_bb_0</value></param>
</block>
<block>
<key>lsa_packet_sink</key>
<param><key>id</key><value>lsa_packet_sink_0</value></param>
<param><key>thres</key><value>10</value></param>
</block>
<block>
<key>lsa_su_ctrl</key>
<param><key>id</key><value>lsa_su_ctrl_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>lsa_su_sr_transmitter_bb</key>
<param><key>id</key><value>lsa_su_sr_transmitter_bb_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>lsa_su_tx_helper</key>
<param><key>id</key><value>lsa_su_tx_helper_0</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.00016</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_subdev</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_ctrl</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lsa_su_sr_transmitter_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>lsa_packet_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_chip_mapper_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_packet_sink_0</source_block_id><sink_block_id>lsa_su_ctrl_0</sink_block_id><source_key>pkt_out</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>lsa_su_ctrl_0</source_block_id><sink_block_id>lsa_su_tx_helper_0</sink_block_id><source_key>ctrl_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>lsa_su_sr_transmitter_bb_0</source_block_id><sink_block_id>lsa_chip_mapper_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_su_tx_helper_0</source_block_id><sink_block_id>lsa_su_sr_transmitter_bb_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
