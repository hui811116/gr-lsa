<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sim_interference_detector</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>accesscode</value></param>
<param><key>value</key><value>"11110000110010100101001101101001"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod_s</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>preamble</value></param>
<param><key>data</key><value>preamble_ac</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(mod_s, False, sps, True, eb, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_ac</value></param>
<param><key>value</key><value>[0xf0,0xca,0x53,0x69,0x00,0x00]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qam_samp</value></param>
<param><key>value</key><value>num*8/4*2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>sps*nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_1</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>4</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>qam_samp*32,qam_samp</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"pu_packet"</value></param>
<param><key>packet_len</key><value>qam_samp</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>num</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>np.zeros(qam_samp*32)</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>mod_s.arity()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_qam_mod</key>
<param><key>id</key><value>digital_qam_mod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.22</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>16</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lsa_interference_canceller_cc</key>
<param><key>id</key><value>lsa_interference_canceller_cc_0</value></param>
<param><key>bps</key><value>mod_s.bits_per_symbol()</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>hdr_bits</key><value>len(accesscode) + 64</value></param>
<param><key>sense</key><value>"interference_tag"</value></param>
</block>
<block>
<key>lsa_interference_energy_detector_cc</key>
<param><key>id</key><value>lsa_interference_energy_detector_cc_0</value></param>
<param><key>blocklength</key><value>128</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>ed_thres</key><value>1</value></param>
<param><key>ed_tagname</key><value>"energy_tag"</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>voe_tagname</key><value>"interference_tag"</value></param>
<param><key>voe_thres</key><value>1</value></param>
</block>
<block>
<key>lsa_modified_costas_loop_cc</key>
<param><key>id</key><value>lsa_modified_costas_loop_cc_0</value></param>
<param><key>tagname</key><value>"interference_tag"</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>mod_s.arity()</value></param>
<param><key>use_snr</key><value>False</value></param>
</block>
<block>
<key>lsa_modified_polyphase_time_sync_cc</key>
<param><key>id</key><value>lsa_modified_polyphase_time_sync_cc_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>tagname</key><value>"interference_tag"</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
</block>
<block>
<key>lsa_prou_sample_queue_cc</key>
<param><key>id</key><value>lsa_prou_sample_queue_cc_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sense_tagname</key><value>"interference_tag"</value></param>
</block>
<block>
<key>lsa_su_transmitter_bc</key>
<param><key>id</key><value>lsa_su_transmitter_bc_0</value></param>
<param><key>accesscode</key><value>accesscode</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>hdr_points</key><value>mod_s.points()</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>pld_points</key><value>mod_s.points()</value></param>
<param><key>qmax</key><value>1024</value></param>
<param><key>sensing_tag</key><value>"interference_tag"</value></param>
</block>
<block>
<key>lsa_symbol_receiver_c</key>
<param><key>id</key><value>lsa_symbol_receiver_c_0</value></param>
<param><key>hdr</key><value>mod_s</value></param>
<param><key>pld</key><value>mod_s</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>accesscode</key><value>accesscode</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sense_tag</key><value>"sensing"</value></param>
</block>
<block>
<key>lsa_symbol_receiver_c</key>
<param><key>id</key><value>lsa_symbol_receiver_c_1</value></param>
<param><key>hdr</key><value>mod_s</value></param>
<param><key>pld</key><value>mod_s</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>accesscode</key><value>accesscode</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sense_tag</key><value>"interference_tag"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_qam_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>lsa_su_transmitter_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lsa_interference_energy_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_qam_mod_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_interference_canceller_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_prou_sample_queue_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_receiver_c_1</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>lsa_modified_polyphase_time_sync_cc_0</source_block_id><sink_block_id>lsa_modified_costas_loop_cc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_modified_polyphase_time_sync_cc_0</source_block_id><sink_block_id>lsa_modified_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_modified_polyphase_time_sync_cc_0</source_block_id><sink_block_id>lsa_modified_costas_loop_cc_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lsa_prou_sample_queue_cc_0</source_block_id><sink_block_id>lsa_modified_polyphase_time_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_prou_sample_queue_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_prou_sample_queue_cc_0</source_block_id><sink_block_id>lsa_interference_canceller_cc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_prou_sample_queue_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_su_transmitter_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_symbol_receiver_c_0</source_block_id><sink_block_id>lsa_su_transmitter_bc_0</sink_block_id><source_key>info</source_key><sink_key>sensing_info</sink_key></connection>
<connection><source_block_id>lsa_symbol_receiver_c_1</source_block_id><sink_block_id>lsa_prou_sample_queue_cc_0</sink_block_id><source_key>info</source_key><sink_key>info</sink_key></connection>
</flow_graph>
