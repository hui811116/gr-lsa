<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_lsa_loopback</value></param>
<param><key>author</key><value>TH huang</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac</value></param>
<param><key>value</key><value>digital.packet_utils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_hex</value></param>
<param><key>value</key><value>[int(ac[i:i+8],2) for i in range(0,len(ac),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>acc_bits</value></param>
<param><key>value</key><value>[int(ac[i:i+bps],2) for i in range(0,len(ac),bps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>sps/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_ctrl</value></param>
<param><key>value</key><value>2.3e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_bytes</value></param>
<param><key>value</key><value>[int(ac[i:i+8],2) for i in range(0,len(ac),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_s</value></param>
<param><key>value</key><value>[mod.points()[acc_bits[i]] for i in range(0,len(acc_bits)) ]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>pre_smp</value></param>
<param><key>data</key><value>ac_hex</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>rxmod</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_ctrl_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>label</key><value>RX CTRL gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_ctrl_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_data_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>label</key><value>RX DATA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_data_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxmod</value></param>
<param><key>value</key><value>digital.generic_mod(mod, False, sps, True, 0.35, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>thres</value></param>
<param><key>value</key><value>-50</value></param>
<param><key>label</key><value>ED threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-80</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_ctrl_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>TX CTRL channel gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_ctrl_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_data_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>TX DATA channel gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_data_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>LSA_ctrl</key>
<param><key>id</key><value>LSA_ctrl_0</value></param>
<param><key>mod</key><value>mod</value></param>
<param><key>preamble_s</key><value>pre_s</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>eb</key><value>eb</value></param>
<param><key>rx_rrc_taps</key><value>rx_rrc_taps</value></param>
</block>
<block>
<key>LSA_phy</key>
<param><key>id</key><value>LSA_phy_0</value></param>
<param><key>mod</key><value>mod</value></param>
<param><key>preamble_s</key><value>pre_s</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>eb</key><value>eb</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>lsa_app_simple</key>
<param><key>id</key><value>lsa_app_simple_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>dest</key><value>87</value></param>
</block>
<block>
<key>lsa_burst_parser_cc</key>
<param><key>id</key><value>lsa_burst_parser_cc_0</value></param>
<param><key>min_len</key><value>200</value></param>
</block>
<block>
<key>lsa_eng_det_cc</key>
<param><key>id</key><value>lsa_eng_det_cc_0</value></param>
<param><key>bin</key><value>50</value></param>
<param><key>threshold</key><value>thres</value></param>
</block>
<block>
<key>lsa_mac</key>
<param><key>id</key><value>lsa_mac_0</value></param>
<param><key>addr</key><value>100</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_data_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>tx_data_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>A:B</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq_ctrl</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_ctrl_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>tx_ctrl_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq_ctrl</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_ctrl_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>rx_ctrl_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:B</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_data_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>rx_data_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>LSA_ctrl_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>LSA_ctrl_0</source_block_id><sink_block_id>lsa_mac_0</sink_block_id><source_key>from_ctrl</source_key><sink_key>from_ctrl</sink_key></connection>
<connection><source_block_id>LSA_phy_0</source_block_id><sink_block_id>lsa_mac_0</sink_block_id><source_key>from_phy</source_key><sink_key>phy_in</sink_key></connection>
<connection><source_block_id>LSA_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>LSA_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_app_simple_0</source_block_id><sink_block_id>lsa_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>lsa_burst_parser_cc_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_eng_det_cc_0</source_block_id><sink_block_id>lsa_burst_parser_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_mac_0</source_block_id><sink_block_id>lsa_app_simple_0</sink_block_id><source_key>msg_out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>lsa_mac_0</source_block_id><sink_block_id>LSA_ctrl_0</sink_block_id><source_key>to_ctrl</source_key><sink_key>from_mac</sink_key></connection>
<connection><source_block_id>lsa_mac_0</source_block_id><sink_block_id>LSA_phy_0</sink_block_id><source_key>to_phy</source_key><sink_key>from_mac</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>LSA_ctrl_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>lsa_eng_det_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
