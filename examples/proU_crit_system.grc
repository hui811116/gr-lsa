<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>prou_critical_system</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_bits</value></param>
<param><key>value</key><value>[int(cross_ac[i:i+bps],2) for i in range(0,len(cross_ac),bps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_qpsk</value></param>
<param><key>value</key><value>[mod.points()[ac_bits[i]] for i in range(0,len(ac_bits))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cross_ac</value></param>
<param><key>value</key><value>digital.packet_utils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"addr=192.168.10.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.5e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1-1j, 1+1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_bytes</value></param>
<param><key>value</key><value>[int(cross_ac[i:i+8],2) for i in range(0,len(cross_ac),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_sym</value></param>
<param><key>value</key><value>[int(cross_ac[i:i+bps],2) for i in range(0,len(cross_ac),bps)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>preamble</value></param>
<param><key>data</key><value>pre_bytes</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>rxmod</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>gui_hint</key><value>tab1@0:0,0,1,2</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>32</value></param>
<param><key>ntaps</key><value>11*4*32</value></param>
<param><key>samp_rate</key><value>32*4</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxmod</value></param>
<param><key>value</key><value>digital.generic_mod(mod, False, 4, True, 0.35, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>voe_thres</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>tab1@0:0,2,1,2</value></param>
<param><key>label</key><value>VOE threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_symbol</value></param>
<param><key>value</key><value>"11011001110000110101001000101110"</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>gain_omega</key><value>0.000225</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.0002</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lsa_block_tagger_cc</key>
<param><key>id</key><value>lsa_block_tagger_cc_0</value></param>
<param><key>bsize</key><value>8192</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tagname</key><value>"block_tag"</value></param>
</block>
<block>
<key>lsa_coarse_sync_cc</key>
<param><key>id</key><value>lsa_coarse_sync_cc_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>thres</key><value>0.80</value></param>
</block>
<block>
<key>lsa_correlate_sync_cc</key>
<param><key>id</key><value>lsa_correlate_sync_cc_0</value></param>
<param><key>samples</key><value>ac_qpsk</value></param>
<param><key>thres</key><value>0.75</value></param>
</block>
<block>
<key>lsa_correlate_sync_cc</key>
<param><key>id</key><value>lsa_correlate_sync_cc_0_0</value></param>
<param><key>samples</key><value>preamble</value></param>
<param><key>thres</key><value>0.54</value></param>
</block>
<block>
<key>lsa_expand_symbol_to_sample_ff</key>
<param><key>id</key><value>lsa_expand_symbol_to_sample_ff_0</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>lsa_ic_critical_cc</key>
<param><key>id</key><value>lsa_ic_critical_cc_0</value></param>
<param><key>block_size</key><value>8192</value></param>
<param><key>cross_word</key><value>preamble</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>lsa_interference_energy_detector_cc</key>
<param><key>id</key><value>lsa_interference_energy_detector_cc_0</value></param>
<param><key>blocklength</key><value>128</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>lsa_interference_tagger_cc</key>
<param><key>id</key><value>lsa_interference_tagger_cc_0</value></param>
<param><key>voe_thres</key><value>voe_thres</value></param>
</block>
<block>
<key>lsa_modified_costas_loop_cc</key>
<param><key>id</key><value>lsa_modified_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>4</value></param>
<param><key>use_snr</key><value>False</value></param>
</block>
<block>
<key>lsa_moving_average_cc</key>
<param><key>id</key><value>lsa_moving_average_cc_0</value></param>
<param><key>length</key><value>window</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_0</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_1</value></param>
<param><key>length</key><value>window</value></param>
</block>
<block>
<key>lsa_prou_packet_sink_f</key>
<param><key>id</key><value>lsa_prou_packet_sink_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>thres</key><value>10</value></param>
</block>
<block>
<key>lsa_sinr_helper</key>
<param><key>id</key><value>lsa_sinr_helper_0</value></param>
<param><key>hislen</key><value>64</value></param>
<param><key>period</key><value>3000</value></param>
</block>
<block>
<key>lsa_symbol_sync_receiver_cf</key>
<param><key>id</key><value>lsa_symbol_sync_receiver_cf_0</value></param>
<param><key>hdr_const</key><value>mod</value></param>
<param><key>thres</key><value>10</value></param>
</block>
<block>
<key>lsa_throughput_report</key>
<param><key>id</key><value>lsa_throughput_report_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hisLen</key><value>64</value></param>
<param><key>ms</key><value>6000</value></param>
<param><key>user</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@1:0,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Variance of energy</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@0:0,0,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IC I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>IC Q</value></param>
<param><key>name</key><value>IC Signals</value></param>
<param><key>size</key><value>100000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"ic_out"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@0:0,2,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>IC I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>IC Q</value></param>
<param><key>name</key><value>Comparison of Signals</value></param>
<param><key>size</key><value>100000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"ic_out"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@4:0,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Received</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Canceled</value></param>
<param><key>marker2</key><value>2</value></param>
<param><key>name</key><value>SINR Comparison</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>SINR</value></param>
<param><key>yunit</key><value>"dB"</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@2:0,0,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Autocorrelation</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value></value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab0@2:0,2,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Cross correlation</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value></value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab0@3:0,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>ProU</value></param>
<param><key>name</key><value>Goodput of ProU</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Goodput</value></param>
<param><key>yunit</key><value>"Bytes/s"</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.00016</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab0</value></param>
<param><key>gui_hint</key><value>1,0,2,4</value></param>
<param><key>label0</key><value>Signal</value></param>
<param><key>label1</key><value>Detector</value></param>
<param><key>label2</key><value>Correlation</value></param>
<param><key>label3</key><value>Throughput</value></param>
<param><key>label4</key><value>SINR</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label0</key><value>Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>qtgui_time_sink_x_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>lsa_moving_average_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lsa_moving_average_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_nlog10_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_nlog10_ff_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_2</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>lsa_prou_packet_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>lsa_correlate_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_block_tagger_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_block_tagger_cc_0</source_block_id><sink_block_id>lsa_correlate_sync_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_coarse_sync_cc_0</source_block_id><sink_block_id>lsa_block_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_correlate_sync_cc_0</source_block_id><sink_block_id>lsa_modified_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_correlate_sync_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_correlate_sync_cc_0_0</source_block_id><sink_block_id>lsa_ic_critical_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_expand_symbol_to_sample_ff_0</source_block_id><sink_block_id>lsa_ic_critical_cc_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lsa_expand_symbol_to_sample_ff_0</source_block_id><sink_block_id>lsa_ic_critical_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_ic_critical_cc_0</source_block_id><sink_block_id>lsa_sinr_helper_0</sink_block_id><source_key>SINR</source_key><sink_key>SINR_in</sink_key></connection>
<connection><source_block_id>lsa_ic_critical_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_ic_critical_cc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_ic_critical_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_moving_average_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_sync_receiver_cf_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_sync_receiver_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_modified_costas_loop_cc_0</source_block_id><sink_block_id>lsa_symbol_sync_receiver_cf_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_prou_packet_sink_f_0</source_block_id><sink_block_id>lsa_throughput_report_0</sink_block_id><source_key>pkt_out</source_key><sink_key>pkt_in</sink_key></connection>
<connection><source_block_id>lsa_sinr_helper_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>cSINR_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lsa_sinr_helper_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>oSINR_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lsa_symbol_sync_receiver_cf_0</source_block_id><sink_block_id>lsa_expand_symbol_to_sample_ff_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_symbol_sync_receiver_cf_0</source_block_id><sink_block_id>lsa_expand_symbol_to_sample_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_throughput_report_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_2</sink_block_id><source_key>tp_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lsa_interference_energy_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
