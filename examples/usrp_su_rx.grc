<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_su_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"name=NicB210"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>e6</value></param>
<param><key>value</key><value>"1001011000000111011110111000110011000011010100100010111011011001"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>e6_points</value></param>
<param><key>value</key><value>[mod.points()[e6_sym[i]] for i in range(0,len(e6_sym))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>e6_sym</value></param>
<param><key>value</key><value>[int(e6[i:i+2],2) for i in range(0,len(e6),2)]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ed_thres</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab0@0:1,2,1,2</value></param>
<param><key>label</key><value>ED threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_ctrl</value></param>
<param><key>value</key><value>2.48e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.6e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1-1j, 1+1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tab0@0:0,2,1,2</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab0@0:0,0,1,2</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>voe_thres</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>tab0@0:1,0,1,2</value></param>
<param><key>label</key><value>VOE threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_symbol</value></param>
<param><key>value</key><value>"11011001110000110101001000101110"</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>128</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>mod.arity()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import sin,pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>lsa_burst_tagger_cc</key>
<param><key>id</key><value>lsa_burst_tagger_cc_0</value></param>
<param><key>mult</key><value>8*8/2*sps</value></param>
<param><key>tagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>lsa_byte_to_symbol_bc</key>
<param><key>id</key><value>lsa_byte_to_symbol_bc_0</value></param>
</block>
<block>
<key>lsa_coarse_sync_cc</key>
<param><key>id</key><value>lsa_coarse_sync_cc_0</value></param>
<param><key>delay</key><value>128</value></param>
<param><key>thres</key><value>0.95</value></param>
</block>
<block>
<key>lsa_correlate_sync_cc</key>
<param><key>id</key><value>lsa_correlate_sync_cc_0</value></param>
<param><key>samples</key><value>e6_points</value></param>
<param><key>thres</key><value>0.95</value></param>
</block>
<block>
<key>lsa_interference_energy_detector_cc</key>
<param><key>id</key><value>lsa_interference_energy_detector_cc_0</value></param>
<param><key>blocklength</key><value>128</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>lsa_interference_tagger_cc</key>
<param><key>id</key><value>lsa_interference_tagger_cc_0</value></param>
<param><key>voe_thres</key><value>voe_thres</value></param>
</block>
<block>
<key>lsa_moving_average_cc</key>
<param><key>id</key><value>lsa_moving_average_cc_0</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_0</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_1</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_phy_crc</key>
<param><key>id</key><value>lsa_phy_crc_0</value></param>
<param><key>user</key><value>1</value></param>
</block>
<block>
<key>lsa_preamble_prefixer</key>
<param><key>id</key><value>lsa_preamble_prefixer_0</value></param>
<param><key>user</key><value>0</value></param>
</block>
<block>
<key>lsa_su_ctrl</key>
<param><key>id</key><value>lsa_su_ctrl_0</value></param>
</block>
<block>
<key>lsa_su_packet_sink_c</key>
<param><key>id</key><value>lsa_su_packet_sink_c_0</value></param>
<param><key>hdr_const</key><value>mod</value></param>
<param><key>thres</key><value>10</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab1@0</value></param>
<param><key>name</key><value>Data channel Const</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@1:0,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>10000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab0</value></param>
<param><key>gui_hint</key><value>0,0,2,4</value></param>
<param><key>label0</key><value>Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>label0</key><value>Const</value></param>
<param><key>label1</key><value>VoE</value></param>
<param><key>label2</key><value>Throughput</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_ctrl</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_subdev</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>lsa_moving_average_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>lsa_burst_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lsa_moving_average_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>lsa_byte_to_symbol_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>lsa_su_packet_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>lsa_correlate_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_burst_tagger_cc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_byte_to_symbol_bc_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_coarse_sync_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_correlate_sync_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_moving_average_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_phy_crc_0</source_block_id><sink_block_id>lsa_su_ctrl_0</sink_block_id><source_key>pdu_out</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>lsa_preamble_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lsa_su_ctrl_0</source_block_id><sink_block_id>lsa_preamble_prefixer_0</sink_block_id><source_key>ctrl_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lsa_su_packet_sink_c_0</source_block_id><sink_block_id>lsa_phy_crc_0</sink_block_id><source_key>msg</source_key><sink_key>phy_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lsa_interference_energy_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
