<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>packet_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>framebits</key><value>hdr_format.header_nbits()</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>hdr_const</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>soft_dec_lut</key><value>"auto"</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>value</key><value>digital.header_format_counter(digital.packet_utils.default_access_code, 3, pld_const.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>soft_dec_lut</key><value>"auto"</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rep</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_by_tag_value_cc</key>
<param><key>id</key><value>blocks_multiply_by_tag_value_cc_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>2000</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>c</key><value>pld_const.bits_per_symbol()</value></param>
<param><key>lengthtagname</key><value>payload_symbols</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>pld_const</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_1</value></param>
<param><key>constellation</key><value>hdr_const</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>mark_delay</key><value>34</value></param>
<param><key>threshold</key><value>0.999</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>header_len</key><value>(hdr_format.header_nbits() * int(1.0/dec_hdr.rate())) /  hdr_const.bits_per_symbol()</value></param>
<param><key>header_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>items_per_symbol</key><value>1</value></param>
<param><key>length_tag_key</key><value>"payload_symbols"</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>special_tags</key><value>""</value></param>
<param><key>timing_tag_key</key><value>"rx_time"</value></param>
<param><key>trigger_tag_key</key><value>"time_est"</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>0.628/100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_protocol_parser_b</key>
<param><key>id</key><value>digital_protocol_parser_b_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>dec</value></param>
<param><key>mtu</key><value>1500*8</value></param>
</block>
<block>
<key>fec_generic_decoder</key>
<param><key>id</key><value>fec_generic_decoder_0</value></param>
<param><key>decoder</key><value>dec_hdr</value></param>
<param><key>itype</key><value>float</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>packet_tx</key>
<param><key>id</key><value>packet_tx_0</value></param>
<param><key>hdr_enc</key><value>enc_hdr</value></param>
<param><key>hdr_format</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
<param><key>hdr_const</key><value>hdr_const</value></param>
<param><key>pld_enc</key><value>enc</value></param>
<param><key>pld_const</key><value>pld_const</value></param>
<param><key>psf_taps</key><value>tx_rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_by_tag_value_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>packet_tx_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_1</source_block_id><sink_block_id>fec_generic_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_multiply_by_tag_value_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_parser_b_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>info</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_generic_decoder_0</source_block_id><sink_block_id>digital_protocol_parser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>packet_tx_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
