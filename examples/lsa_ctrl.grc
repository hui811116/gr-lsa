<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LSA_ctrl</value></param>
<param><key>author</key><value>Teng-Hui Huang</value></param>
<param><key>category</key><value>[lsa]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LSA_ctrl</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac</value></param>
<param><key>value</key><value>digital.packet_utils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_hex</value></param>
<param><key>value</key><value>[int(ac[i:i+8],2) for i in range(0,len(ac),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>acc_bits</value></param>
<param><key>value</key><value>[int(ac[i:i+bps],2) for i in range(0,len(ac),bps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_bytes</value></param>
<param><key>value</key><value>[int(preamble[i:i+8],2) for i in range(0,len(preamble),8)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_s</value></param>
<param><key>value</key><value>[mod.points()[acc_bits[i]] for i in range(0,len(acc_bits)) ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>digital.packet_utils.default_access_code</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>mod.bits_per_symbol()</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>mod</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>mod</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>eb</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>pre_s</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold</key><value>0.95</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>mod.arity()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>eb</value></param>
<param><key>label</key><value>excess bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>sps/2</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lsa_burst_tagger_cc</key>
<param><key>id</key><value>lsa_burst_tagger_cc_0</value></param>
<param><key>tagname</key><value>"packet_len"</value></param>
<param><key>mult</key><value>sps*8/mod.bits_per_symbol()</value></param>
</block>
<block>
<key>lsa_packet_parser_b</key>
<param><key>id</key><value>lsa_packet_parser_b_0</value></param>
<param><key>accesscode</key><value>1010011111111111</value></param>
</block>
<block>
<key>lsa_preamble_prefixer</key>
<param><key>id</key><value>lsa_preamble_prefixer_0</value></param>
<param><key>preamble</key><value>pre_bytes</value></param>
</block>
<block>
<key>lsa_symbol_corrector_cc</key>
<param><key>id</key><value>lsa_symbol_corrector_cc_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod</value></param>
<param><key>label</key><value>Constellation object</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>ctrl_out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>from_ctrl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>from_mac</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>wav_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>label</key><value>rx matched filter taps</value></param>
<param><key>value</key><value>[0,]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples/symbol</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>lsa_packet_parser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>lsa_burst_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>lsa_symbol_corrector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_burst_tagger_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_packet_parser_b_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lsa_preamble_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lsa_symbol_corrector_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lsa_preamble_prefixer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
