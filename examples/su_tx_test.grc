<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>su_tx_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>accesscode</value></param>
<param><key>value</key><value>"1111010100000111"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>100</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>len(accesscode)/8+8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>lsa_my_access_corr_bb</key>
<param><key>id</key><value>lsa_my_access_corr_bb_0</value></param>
<param><key>access_code</key><value>accesscode</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>lsa_su_queued_transmitter_cc</key>
<param><key>id</key><value>lsa_su_queued_transmitter_cc_0</value></param>
<param><key>accesscode</key><value>accesscode</value></param>
<param><key>max_queue_size</key><value>1024</value></param>
<param><key>index_tag</key><value>"packet_index"</value></param>
<param><key>sensing_tag</key><value>"sensing_info"</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>lsa_su_queued_transmitter_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>lsa_my_access_corr_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lsa_my_access_corr_bb_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>info</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lsa_su_queued_transmitter_cc_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_su_queued_transmitter_cc_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
