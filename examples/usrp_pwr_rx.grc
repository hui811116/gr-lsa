<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_pwr_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>mod.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"name=NicB210"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"addr=192.168.10.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_ctrl</value></param>
<param><key>value</key><value>2.48e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.6e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>mod</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1-1j, 1+1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>gui_hint</key><value>tab0@0:0,2,1,2</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>tab0@0:0,0,1,2</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>voe_thres</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>gui_hint</key><value>tab0@0:1,0,1,2</value></param>
<param><key>label</key><value>VOE threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_points</value></param>
<param><key>value</key><value>[mod.points()[zero_sym[i]] for i in range(0,len(zero_sym))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_samples</value></param>
<param><key>value</key><value>[ (0.43095961-0.11563824j),(0.47927102+0.15876304j),(0.42777519+0.38207836j),(0.22815121+0.51324301j),(-0.08058941+0.54975203j),(-0.36553886+0.49707116j),(-0.47057650+0.36263433j),(-0.32040480+0.15557772j),(0.01811341-0.08735843j),(0.35616438-0.29563213j),(0.49296856-0.38888100j),(0.34317785-0.32049402j),(-0.00822166-0.11057076j),(-0.35212207+0.15988440j),(-0.48621845+0.39268921j),(-0.34024672+0.52175552j),(-0.01134439+0.53407547j),(0.30715390+0.45951832j),(0.44727174+0.33043774j),(0.35677215+0.17166127j),(0.10692448-0.00339739j),(-0.17468070-0.18443709j),(-0.38882848-0.34554769j),(-0.50429878-0.45963016j),(-0.53330871-0.50724829j),(-0.48812694-0.47671898j),(-0.36938445-0.36643642j),(-0.17149539-0.18886194j),(0.07864466+0.02633507j),(0.30238468+0.23356573j),(0.40688034+0.38207836j),(0.33094214+0.43844031j),(0.09440210+0.40972346j),(-0.19959374+0.34241184j),(-0.42777519+0.30510376j),(-0.50782848+0.33390951j),(-0.44477230+0.40684394j),(-0.32689260+0.45727260j),(-0.26379967+0.40924385j),(-0.31021049+0.23941149j),(-0.42783687-0.00676902j),(-0.50640125-0.24207825j),(-0.44577452-0.39268921j),(-0.21822164-0.43956168j),(0.10234910-0.41479095j),(0.36988703-0.37193744j),(0.44871644-0.34549516j),(0.29619552-0.33498316j),(-0.01016641-0.32430978j),(-0.31163810-0.31231295j),(-0.44727174-0.32074571j),(-0.35228795-0.37043354j),(-0.08541368-0.44934767j),(0.21873190-0.49471360j),(0.42633049-0.42633049j),(0.48653382-0.21055213j),(0.43918127+0.09752483j),(0.36317073+0.36604912j),(0.32219041+0.45113247j),(0.32173225+0.30053738j),(0.33107880-0.00482427j),(0.32823061-0.29670578j),(0.32749583-0.42927241j),(0.36148931-0.35001961j),(0.43095961-0.11563824j),(0.47927102+0.15876304j),(0.42777519+0.38207836j),(0.22815121+0.51324301j),(-0.08058941+0.54975203j),(-0.36553886+0.49707116j),(-0.47057650+0.36263433j),(-0.32040480+0.15557772j),(0.01811341-0.08735843j),(0.35616438-0.29563213j),(0.49296856-0.38888100j),(0.34317785-0.32049402j),(-0.00822166-0.11057076j),(-0.35212207+0.15988440j),(-0.48621845+0.39268921j),(-0.34024672+0.52175552j),(-0.01134439+0.53407547j),(0.30715390+0.45951832j),(0.44727174+0.33043774j),(0.35677215+0.17166127j),(0.10692448-0.00339739j),(-0.17468070-0.18443709j),(-0.38882848-0.34554769j),(-0.50429878-0.45963016j),(-0.53330871-0.50724829j),(-0.48812694-0.47671898j),(-0.36938445-0.36643642j),(-0.17149539-0.18886194j),(0.07864466+0.02633507j),(0.30238468+0.23356573j),(0.40688034+0.38207836j),(0.33094214+0.43844031j),(0.09440210+0.40972346j),(-0.19959374+0.34241184j),(-0.42777519+0.30510376j),(-0.50782848+0.33390951j),(-0.44477230+0.40684394j),(-0.32689260+0.45727260j),(-0.26379967+0.40924385j),(-0.31021049+0.23941149j),(-0.42783687-0.00676902j),(-0.50640125-0.24207825j),(-0.44577452-0.39268921j),(-0.21822164-0.43956168j),(0.10137673-0.41576332j),(0.36663785-0.37518662j),(0.44606373-0.34814788j),(0.29703623-0.33414245j),(-0.00508320-0.32117133j),(-0.30475752-0.31193073j),(-0.44534138-0.32412077j),(-0.35783831-0.37430248j),(-0.09388139-0.44764898j),(0.21522759-0.48445674j),(0.43339980-0.41540046j),(0.49730824-0.21087843j),(0.43859227+0.08000041j),(0.34357119+0.33944096j),(0.29492540+0.43800607j),(0.31876207+0.31911603j),(0.37945784+0.04043203j),(0.41452524-0.25610859j),(0.38470481-0.43189885j),(0.29131595-0.42445193j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_sym</value></param>
<param><key>value</key><value>[int(zero_symbol[i:i+2],2) for i in range(0,len(zero_symbol),2)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zero_symbol</value></param>
<param><key>value</key><value>"11011001110000110101001000101110"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zigPre</value></param>
<param><key>value</key><value>[(0.00000000+0.00000000j),(0.70710677+0.00000000j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(-0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(-0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(-0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(-0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677+0.70710677j),(0.00000000+1.00000000j),(-0.70710677+0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(-0.70710677-0.70710677j),(-1.00000000+0.00000000j),(-0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j),(0.00000000-1.00000000j),(0.70710677-0.70710677j),(1.00000000+0.00000000j),(0.70710677+0.70710677j),(0.00000000+1.00000000j),(0.70710677+0.70710677j),(1.00000000+0.00000000j),(0.70710677-0.70710677j)]</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>128</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"burst_tag"</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0, sin(pi/4), 1, sin(3*pi/4)]</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>mod.arity()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>lsa_burst_tagger_cc</key>
<param><key>id</key><value>lsa_burst_tagger_cc_0</value></param>
<param><key>mult</key><value>8*8/2*sps</value></param>
<param><key>tagname</key><value>"burst_tag"</value></param>
</block>
<block>
<key>lsa_byte_to_symbol_bc</key>
<param><key>id</key><value>lsa_byte_to_symbol_bc_0</value></param>
</block>
<block>
<key>lsa_coarse_sync_cc</key>
<param><key>id</key><value>lsa_coarse_sync_cc_0</value></param>
<param><key>delay</key><value>128</value></param>
<param><key>thres</key><value>0.95</value></param>
</block>
<block>
<key>lsa_correlate_sync_cc</key>
<param><key>id</key><value>lsa_correlate_sync_cc_0</value></param>
<param><key>samples</key><value>zero_points</value></param>
<param><key>thres</key><value>0.95</value></param>
</block>
<block>
<key>lsa_interference_energy_detector_cc</key>
<param><key>id</key><value>lsa_interference_energy_detector_cc_0</value></param>
<param><key>blocklength</key><value>128</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>lsa_interference_tagger_cc</key>
<param><key>id</key><value>lsa_interference_tagger_cc_0</value></param>
<param><key>voe_thres</key><value>voe_thres</value></param>
</block>
<block>
<key>lsa_moving_average_cc</key>
<param><key>id</key><value>lsa_moving_average_cc_0</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_0</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_moving_average_ff</key>
<param><key>id</key><value>lsa_moving_average_ff_1</value></param>
<param><key>length</key><value>128</value></param>
</block>
<block>
<key>lsa_phy_crc</key>
<param><key>id</key><value>lsa_phy_crc_0</value></param>
<param><key>user</key><value>2</value></param>
</block>
<block>
<key>lsa_preamble_prefixer</key>
<param><key>id</key><value>lsa_preamble_prefixer_0</value></param>
<param><key>user</key><value>0</value></param>
</block>
<block>
<key>lsa_pwr_rx_state_ctrl_cc</key>
<param><key>id</key><value>lsa_pwr_rx_state_ctrl_cc_0</value></param>
<param><key>gapLen</key><value>2560</value></param>
<param><key>samples</key><value>zigPre</value></param>
<param><key>thres</key><value>0.75</value></param>
</block>
<block>
<key>lsa_stop_n_wait_ack</key>
<param><key>id</key><value>lsa_stop_n_wait_ack_0</value></param>
</block>
<block>
<key>lsa_su_packet_sink_c</key>
<param><key>id</key><value>lsa_su_packet_sink_c_0</value></param>
<param><key>hdr_const</key><value>mod</value></param>
<param><key>thres</key><value>10</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab1@0:0,0,2,2</value></param>
<param><key>name</key><value>"Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@2:0,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Cross correlation</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab1@1:0,0,2,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Variance of energy</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab0</value></param>
<param><key>gui_hint</key><value>0,0,2,4</value></param>
<param><key>label0</key><value>Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>gui_hint</key><value>2,0,2,4</value></param>
<param><key>label0</key><value>Const</value></param>
<param><key>label1</key><value>Energy</value></param>
<param><key>label2</key><value>Corr</value></param>
<param><key>label3</key><value>Debug</value></param>
<param><key>label4</key><value>Throughput</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_ctrl</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_subdev</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>lsa_moving_average_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>lsa_burst_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lsa_moving_average_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>lsa_byte_to_symbol_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>lsa_su_packet_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>lsa_correlate_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_burst_tagger_cc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_byte_to_symbol_bc_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_coarse_sync_cc_0</source_block_id><sink_block_id>lsa_pwr_rx_state_ctrl_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_correlate_sync_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_moving_average_ff_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_energy_detector_cc_0</source_block_id><sink_block_id>lsa_interference_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_interference_tagger_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_moving_average_cc_0</source_block_id><sink_block_id>lsa_coarse_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lsa_moving_average_ff_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_phy_crc_0</source_block_id><sink_block_id>lsa_stop_n_wait_ack_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>lsa_preamble_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lsa_pwr_rx_state_ctrl_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_pwr_rx_state_ctrl_cc_0</source_block_id><sink_block_id>lsa_stop_n_wait_ack_0</sink_block_id><source_key>fb_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>lsa_pwr_rx_state_ctrl_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lsa_stop_n_wait_ack_0</source_block_id><sink_block_id>lsa_preamble_prefixer_0</sink_block_id><source_key>msg_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lsa_su_packet_sink_c_0</source_block_id><sink_block_id>lsa_phy_crc_0</sink_block_id><source_key>msg</source_key><sink_key>phy_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lsa_interference_energy_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
